# Keil uVision project car.uvprojx, settings and files
target car (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/APP;../User/PID;../User/OLED;../User/KEY;../User/ENCODER;../User;../User/MOTOR;../User/Line_Tracking_Sensor;../User/LED_PWM;../User/NTC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../User/: Motor_config.h
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/APP
    ../User/APP/: app.c app.h
  group User/PID
    ../User/PID/: alg_pid.c alg_pid.h
  group OLED
    ../User/OLED/: bsp_oled.c bsp_oled.h bsp_oled_config.h bsp_oled_data.h bsp_oled_data.c
  group KEY
    ../User/KEY/: bsp_key.c bsp_key.h
  group MOTOR
    ../User/MOTOR/: bsp_motor.c bsp_motor.h
  group ENCODER
    ../User/ENCODER/: bsp_encoder.c bsp_encoder.h
  group NTC
    ../User/NTC/: bsp_ntc.c bsp_ntc.h
  group Line_Tracking_Sensor
    ../User/Line_Tracking_Sensor/: LT_Sensor.c LT_Sensor.h
  group LED_PWM
    ../User/LED_PWM/: bsp_led.c bsp_led.h
software components: CMSIS:CORE 4.3.0
